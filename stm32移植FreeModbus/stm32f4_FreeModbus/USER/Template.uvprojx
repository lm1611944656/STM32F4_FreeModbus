# Keil uVision project Template.uvprojx, settings and files
target Template (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\LED;..\HARDWARE\TIM;..\HARDWARE\USART;..\SYSTEM;..\HARDWARE\LED;..\freemodbus\modbus\include;..\freemodbus;..\freemodbus\modbus\rtu;..\freemodbus\port
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c
  group HARDWARE
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/TIM/: tim.c
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/: sys.c delay.c
  group modbus_core
    ../freemodbus/modbus/: mb.c
    ../freemodbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../freemodbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../freemodbus/modbus/ascii/: mbascii.c
  group modbus_port
    ../freemodbus/port/: portevent.c portserial.c porttimer.c
